# IAR project Backup of project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8E Atmel ATSAM3X8E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: cstartup_M_cpp.cpp main.cpp
  group defines
    ./: sam3x8e_register_definitions.h sam3x8e_setup_definitions.h wm8731_setup_definitions.h
  group libs
    ./: sam3x8e_adc.h sam3x8e_din.h sam3x8e_dma.h sam3x8e_setup.h sam3x8e_ssc.h sam3x8e_twi.h sam3x8e_wdt.h
  group sources
    ./: sam3x8e_adc.cpp sam3x8e_din.cpp sam3x8e_dma.cpp sam3x8e_setup.cpp sam3x8e_ssc.cpp sam3x8e_twi.cpp sam3x8e_wdt.cpp
